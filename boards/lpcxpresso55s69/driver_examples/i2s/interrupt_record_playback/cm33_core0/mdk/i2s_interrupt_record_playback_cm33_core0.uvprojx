# Keil uVision project i2s_interrupt_record_playback_cm33_core0.uvprojx, settings and files
target i2s_interrupt_record_playback_cm33_core0 debug (6230000::V6.23::ARMCLANG)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.25.03.00
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: i2s_interrupt_record_playback_cm33_core0.out
  AfterMake: fromelf.exe --output "$Li2s_interrupt_record_playback.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_LPC55S69JBD100_cm33_core0, SDK_I2C_BASED_COMPONENT_USED=1, CODEC_MULTI_ADAPTERS=1, CODEC_WM8904_ENABLE
  c misc: -include ../mcux_config.h -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: ..;../../../../../../../devices/LPC55S69/drivers;../../../../../../../CMSIS/Core/Include;../../../../../../../CMSIS/Core/Include/m-profile;../../../../../../../devices/LPC55S69;../../../../../../../devices/LPC55S69/periph;../../../../../../../devices/LPC55S69/utilities/debug_console_lite;../../../../../../../devices/LPC55S69/utilities/str;../../../../../../../components/codec/i2c;../../../../../../../components/codec;../../../../../../../components/codec/port;../../../../../../../components/codec/port/wm8904;../../../../../../../components/codec/wm8904;../../../../../../../components/i2c;../../../../../../../components/uart
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG, KEIL, MCUXPRESSO_SDK, CPU_LPC55S69JBD100_cm33_core0
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC55S69_cm33_core0_flash.scf
  link misc: --remove --entry=Reset_Handler --info=sizes,totals,unused,veneers
  group source
    ../: i2s_interrupt_record_playback.c music.h mcux_config.h
  group board
    ../: board.h board.c clock_config.h clock_config.c pin_mux.c pin_mux.h hardware_init.c app.h
  group drivers
    ../../../../../../../devices/LPC55S69/drivers/: fsl_clock.c fsl_clock.h fsl_inputmux_connections.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_flexcomm.h fsl_flexcomm.c fsl_usart.h fsl_usart.c fsl_spi.c fsl_spi.h fsl_i2s_dma.h fsl_i2s_dma.c fsl_i2s.h fsl_i2s.c fsl_i2c.h fsl_i2c.c fsl_inputmux.h fsl_inputmux.c fsl_dma.c fsl_dma.h fsl_gpio.h fsl_gpio.c fsl_iocon.h fsl_sysctl.h fsl_sysctl.c
  group CMSIS
    ../../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/m-profile
    ../../../../../../../CMSIS/Core/Include/m-profile/: cmsis_armclang_m.h armv8m_mpu.h
  group device
    ../../../../../../../devices/LPC55S69/: fsl_device_registers.h LPC55S69_cm33_core0.h LPC55S69_cm33_core0_COMMON.h LPC55S69_cm33_core0_features.h system_LPC55S69_cm33_core0.c system_LPC55S69_cm33_core0.h
  group device/periph
    ../../../../../../../devices/LPC55S69/periph/: PERI_ADC.h PERI_AHB_SECURE_CTRL.h PERI_ANACTRL.h PERI_CASPER.h PERI_CRC.h PERI_CTIMER.h PERI_DBGMAILBOX.h PERI_DMA.h PERI_FLASH.h PERI_FLASH_CFPA.h PERI_FLASH_CMPA.h PERI_FLASH_KEY_STORE.h PERI_FLEXCOMM.h PERI_GINT.h PERI_GPIO.h PERI_HASHCRYPT.h PERI_I2C.h PERI_I2S.h PERI_INPUTMUX.h PERI_IOCON.h PERI_MAILBOX.h PERI_MRT.h PERI_OSTIMER.h PERI_PINT.h PERI_PLU.h PERI_PMC.h PERI_POWERQUAD.h PERI_PRINCE.h PERI_PUF.h PERI_RNG.h PERI_RTC.h PERI_SCT.h PERI_SDIF.h PERI_SPI.h PERI_SYSCON.h PERI_SYSCTL.h PERI_USART.h PERI_USB.h PERI_USBFSH.h PERI_USBHSD.h PERI_USBHSH.h PERI_USBPHY.h PERI_UTICK.h PERI_WWDT.h
  group startup/arm
    ../../../../../../../devices/LPC55S69/arm/: startup_LPC55S69_cm33_core0.S
  group utilities
    ../../../../../../../devices/LPC55S69/utilities/debug_console_lite/: fsl_assert.h fsl_assert.c
    ../../../../../../../devices/LPC55S69/utilities/: fsl_memcpy.S
  group utilities/str
    ../../../../../../../devices/LPC55S69/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console_lite
    ../../../../../../../devices/LPC55S69/utilities/debug_console_lite/: fsl_debug_console.h fsl_debug_console.c
  group codec
    ../../../../../../../components/codec/i2c/: fsl_codec_i2c.h fsl_codec_i2c.c
    ../../../../../../../components/codec/: fsl_codec_common.h fsl_codec_common.c
    ../../../../../../../components/codec/wm8904/: fsl_wm8904.h fsl_wm8904.c
  group codec/port
    ../../../../../../../components/codec/port/: fsl_codec_adapter.c fsl_codec_adapter.h
  group codec/port/wm8904
    ../../../../../../../components/codec/port/wm8904/: fsl_codec_wm8904_adapter.h fsl_codec_wm8904_adapter.c
  group component/i2c
    ../../../../../../../components/i2c/: fsl_adapter_i2c.h fsl_adapter_flexcomm_i2c.c
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group doc
    ../: readme.md example_board_readme.md
target i2s_interrupt_record_playback_cm33_core0 release (ARM-ADS)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.25.03.00
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: i2s_interrupt_record_playback_cm33_core0.out
  AfterMake: as above
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_LPC55S69JBD100_cm33_core0, SDK_I2C_BASED_COMPONENT_USED=1, CODEC_MULTI_ADAPTERS=1, CODEC_WM8904_ENABLE
  c misc: as above
  c include: as above
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG, KEIL, MCUXPRESSO_SDK, CPU_LPC55S69JBD100_cm33_core0
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC55S69_cm33_core0_flash.scf
  link misc: as above
